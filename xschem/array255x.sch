v {xschem version=3.4.7RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {Last row is never Select-all} 150 -180 0 0 0.2 0.2 {}
T {1st row always enabled for column-select} 140 -390 0 0 0.2 0.2 {}
T {1st row Select-all for R>0} 160 -420 0 0 0.2 0.2 {}
T {Select-all lags 1 row} 160 -300 0 0 0.2 0.2 {}
T {*** REMEMBER ***
Cn, Rn, Sn are active-low} 80 -520 0 0 0.2 0.2 {}
C {row15x.sym} 490 -290 0 0 {name=XIR[14:1]}
C {iopin.sym} 120 -410 0 1 {name=p2 lab=VPWR}
C {opin.sym} 100 -230 0 0 {name=p3 lab=Iout}
C {iopin.sym} 120 -390 0 1 {name=p4 lab=VGND}
C {ipin.sym} 120 -270 0 0 {name=p7 lab=Vbias}
C {lab_pin.sym} 640 -320 0 1 {name=p19 sig_type=std_logic lab=VPWR}
C {lab_pin.sym} 640 -280 0 1 {name=p10 sig_type=std_logic lab=Iout}
C {lab_pin.sym} 340 -320 0 0 {name=p18 sig_type=std_logic lab=Vbias}
C {lab_pin.sym} 640 -300 0 1 {name=p15 sig_type=std_logic lab=VGND}
C {ipin.sym} 120 -300 0 0 {name=p1 lab=Cn[14:0]}
C {lab_pin.sym} 490 -350 0 0 {name=p5 sig_type=std_logic lab=Cn[14:0]}
C {ipin.sym} 120 -320 0 0 {name=p6 lab=Rn[14:0]}
C {lab_pin.sym} 340 -280 0 0 {name=p8 sig_type=std_logic lab=Rn[13:0]}
C {row15x.sym} 490 -410 0 0 {name=XIR[0]}
C {lab_pin.sym} 640 -440 0 1 {name=p9 sig_type=std_logic lab=VPWR}
C {lab_pin.sym} 640 -400 0 1 {name=p11 sig_type=std_logic lab=Iout}
C {lab_pin.sym} 340 -440 0 0 {name=p12 sig_type=std_logic lab=Vbias}
C {lab_pin.sym} 640 -420 0 1 {name=p13 sig_type=std_logic lab=VGND}
C {lab_pin.sym} 490 -470 0 0 {name=p14 sig_type=std_logic lab=Cn[14:0]}
C {lab_pin.sym} 340 -180 0 0 {name=p16 sig_type=std_logic lab=VPWR}
C {lab_pin.sym} 340 -420 0 0 {name=p17 sig_type=std_logic lab=Rn[0]}
C {lab_pin.sym} 340 -300 0 0 {name=p20 sig_type=std_logic lab=Rn[14:1]}
C {row15x.sym} 490 -170 0 0 {name=XIR[15]}
C {lab_pin.sym} 640 -200 0 1 {name=p21 sig_type=std_logic lab=VPWR}
C {lab_pin.sym} 640 -160 0 1 {name=p22 sig_type=std_logic lab=Iout}
C {lab_pin.sym} 340 -200 0 0 {name=p23 sig_type=std_logic lab=Vbias}
C {lab_pin.sym} 640 -180 0 1 {name=p24 sig_type=std_logic lab=VGND}
C {lab_pin.sym} 490 -230 0 0 {name=p25 sig_type=std_logic lab=Cn[14:0]}
C {lab_pin.sym} 340 -160 0 0 {name=p26 sig_type=std_logic lab=Rn[14]}
C {lab_pin.sym} 340 -400 0 0 {name=p27 sig_type=std_logic lab=VGND}
